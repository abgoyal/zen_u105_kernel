## drivers/autotst/Kconfig
```kconfig
config AUTOTST
	bool "Sprd autotest"
	default n
	help
	  AUTOTST is a module for spreadtrum autotest
```
